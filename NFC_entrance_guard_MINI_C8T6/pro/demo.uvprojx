# Keil uVision project demo.uvprojx, settings and files
target projects (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NFC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\app;..\BSP;..\Drivers;..\fwlib\inc;..\lib\FATFS;..\lib\FATFS\option;..\lib\uGUI;..\BSP\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_ld.s
  group fwlib
    ../fwlib/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group app
    ../app/: main.c stm32f10x_it.c systemInit.c app.c
  group bsp
    ../BSP/: Bsp_Usart.c sys.c
    ../Drivers/: delay.c steering_engine.c bsp_iwdg.c
    ../BSP/OLED/: oled.c
  group README
    ../README/: readme.txt
